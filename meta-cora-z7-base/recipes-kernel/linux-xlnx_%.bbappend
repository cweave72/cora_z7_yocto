FILESEXTRAPATHS_prepend_cora-zynq7 := "${THISDIR}/files:"
#SRC_URI_append_cora-zynq7 := "file://coraz7_additions.cfg"
