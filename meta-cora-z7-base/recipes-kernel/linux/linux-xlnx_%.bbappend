FILESEXTRAPATHS_prepend_cora-zynq7 := "${THISDIR}/files:"
COMPATIBLE_MACHINE_cora-zynq7 = ".*"
#SRC_URI_append_cora-zynq7 := "file://coraz7_additions.cfg"
